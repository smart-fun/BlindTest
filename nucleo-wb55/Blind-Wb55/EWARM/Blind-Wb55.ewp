# IAR project Blind-Wb55.ewp, settings and files
configuration Blind-Wb55 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: OPENTHREAD_CONFIG_FILE=<openthread_api_config_ftd.h>; USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Drivers/STM32WBxx_HAL_Driver/Inc; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/utilities; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/ble; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/ble/core/Inc; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/ble/core/Inc/core; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/ble/core/Src/core; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/ble/core/Src/blesvc; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/ble/core/Inc/blesvc; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Drivers/CMSIS/Device/ST/STM32WBxx/Include; C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blind-Wb55.hex
  ILINK.IlinkOutputFile: Blind-Wb55.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c hw_lpm.c hw_timerserver.c hw_uart.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c p2p_server_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Drivers/STM32WBxx_HAL_Driver
    C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_gpio.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Middlewares/STM32_WPAN
    C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c shci_tl.c tl_if.c
    C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c lpm.c otp.c scheduler.c stm_list.c stm_queue.c
    C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/ble/core/Src/core/: osal.c ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    C:/Users/Arnaud/STM32Cube/Repository/STM32Cube_FW_WB_V1.1.1/Middlewares/ST/STM32_WPAN/ble/core/Src/blesvc/: svc_ctl.c p2p_stm.c
